# Keil uVision project WallFollower.uvprojx, settings and files
target WallFollower (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WallFollower +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s ADCSWTrigger.c PLL.c ADCSWTrigger.h PLL.h CECS347Project2.c PWM1.c
    ../: tm4c123gh6pm.h
    ../../CECS347_LABS/Example Labs/ADCSWTrigger/: PWM1.h
